options:
  parameters:
    generate_options: qt_gui
    id: estop
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cov_time
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.1e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '1'
    threshold_factor_fall: '0.025'
    threshold_factor_rise: '0.025'
    type: float
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  \n    \"\"\"Custom block to trigger estop with zero delay and spike rejection\"\"\"\n\n    def __init__(self, threshold_high=300, threshold_low=280, cooldown=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='Estop Trigger',  \n            in_sig=[np.complex64],  \n            out_sig=[]              \n        )\n        self.threshold_high = threshold_high  # Upper threshold for trigger\n        self.threshold_low = threshold_low  # Lower threshold for reset (hysteresis)\n        self.cooldown = cooldown  # Cooldown period (seconds)\n        self.estop_state = 1  # 1 = released, 0 = triggered\n        self.last_toggle_time = -self.cooldown  # Used to track the last trigger time\n        self.previous_sample = 0  # Tracks the last sample to detect edges\n\n        # Force small input chunks to reduce delay\n        self.set_min_noutput_items(1)  # Force processing for small batches\n\n        # Register an output message port for GNU Radio message passing\n        self.message_port_register_out(pmt.intern('estop_state'))\n\n    def work(self, input_items, output_items):\n        current_time = gr.high_res_timer_now() / 1e9  # Get current time in seconds\n        real_part = np.real(input_items[0])  # Extract real part of the input\n        \n        # **1. Edge Detection**\n        # Detect where the signal crosses from below threshold_high to above threshold_high\n        crossing_edge_indices = np.where((real_part[:-1] < self.threshold_high) & (real_part[1:] > self.threshold_high))[0]\n\n        if len(crossing_edge_indices) > 0:  # If we detect a crossing edge\n            if current_time - self.last_toggle_time >= self.cooldown:  # Check cooldown logic\n                # **2. Trigger Estop**\n                self.estop_state = 1 - self.estop_state  # Toggle between 0 (triggered) and 1 (released)\n                self.last_toggle_time = current_time  # Update last toggle time\n\n                # **3. Send Estop State Message**\n                self.message_port_pub(pmt.intern('estop_state'), pmt.from_bool(self.estop_state))\n\n                if self.estop_state == 0:\n                    print(\"Estop Triggered\")\n                else:\n                    print(\"Estop Released\")\n\n        # **4. Update Previous Sample**\n        self.previous_sample = real_part[-1]  # Update the last sample\n\n        return len(input_items[0])\n\n"
    cooldown: '1'
    threshold_high: '500'
    threshold_low: '499'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport time\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):  \n    \"\"\"Embedded Python Block to toggle a variable on input value 1.0 with cooldown\"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Toggle Variable Block',  # Block name\n            in_sig=[np.float32],  # Correct input signal type\n            out_sig=None          # No output signal\n        )\n        self.toggled_variable = False  # Variable to toggle\n        self.last_toggle_time = 0      # Last time the variable was toggled\n        self.cooldown = 2              # Cooldown period in seconds\n\n    def work(self, input_items, output_items):\n        current_time = time.time()  # Get the current time\n        for value in input_items[0]:  # Iterate through input float values\n            if value == 1.0 and (current_time - self.last_toggle_time) >= self.cooldown:\n                # Toggle the variable\n                self.toggled_variable = not self.toggled_variable\n                self.last_toggle_time = current_time  # Update the last toggle time\n                \n                # Print the toggled value\n                print(f\"Toggled Variable: {self.toggled_variable}\")\n        \n        return len(input_items[0])\n\n"
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport time\nimport os\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):  \n    \"\"\"Embedded Python Block to toggle an integer variable on input value 1.0 with cooldown and write to a shared file\"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Toggle Integer to Shared File Block',  # Block name\n            in_sig=[np.float32],  # Accept float input signal\n            out_sig=None          # No output signal\n        )\n        self.toggled_value = 1  # Initialize variable to 1\n        self.last_toggle_time = 0  # Track the last toggle time\n        self.cooldown = 2  # Cooldown period in seconds\n        self.file_path = \"/tmp/estop_value.txt\"  # Shared file location\n\n        # Write the initial value to the file\n        try:\n            with open(self.file_path, 'w') as f:\n                f.write(f\"{self.toggled_value}\\n\")\n            print(f\"Initial value written to file: {self.toggled_value}\")\n        except IOError as e:\n            print(f\"Error writing initial value to file: {e}\")\n\n    def work(self, input_items, output_items):\n        current_time = time.time()  # Get the current time\n\n        for value in input_items[0]:  # Iterate through input float values\n            if value == 1.0 and (current_time - self.last_toggle_time) >= self.cooldown:\n                # Toggle the integer value between 0 and 1\n                self.toggled_value = 1 if self.toggled_value == 0 else 0\n                self.last_toggle_time = current_time  # Update the last toggle time\n\n                # Write the toggled integer value to the shared file\n                try:\n                    with open(self.file_path, 'w') as f:\n                        f.write(f\"{self.toggled_value}\\n\")\n                    print(f\"Toggled value written to file: {self.toggled_value}\")\n                except IOError as e:\n                    print(f\"Error writing to file: {e}\")\n\n        return len(input_items[0])\n\n"
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport time\nimport os\nimport sys\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):  \n    \"\"\"Real-time Toggle Integer Block with Immediate File Updates\"\"\"\n    \n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Real-Time Toggle Integer Block',\n            in_sig=[np.float32],  \n            out_sig=None          \n        )\n        \n        self.toggled_value = 1  \n        self.last_toggle_time = 0  \n        self.cooldown = 2  # Cooldown in seconds\n        self.file_path = \"/tmp/estop_value.txt\"\n\n        # Create or initialize the file\n        with open(self.file_path, \"w\") as f:\n            f.write(\"1\\n\")\n\n    def work(self, input_items, output_items):\n        \"\"\"Real-time processing with forced file updates\"\"\"\n        current_time = time.time()\n        \n        if input_items[0][0] == 1.0 and (current_time - self.last_toggle_time) >= self.cooldown:\n            self.toggled_value = 1 if self.toggled_value == 0 else 0\n            self.last_toggle_time = current_time  \n\n            # **Force an immediate file update**\n            try:\n                with open(self.file_path, 'w') as f:\n                    f.write(f\"{self.toggled_value}\\n\")\n                    f.flush()  # Ensure data is written\n                    os.fsync(f.fileno())  # Force write to disk\n\n                print(f\"[TOGGLED] New Value: {self.toggled_value}\")\n                sys.stdout.flush()  # Ensure immediate output\n\n            except IOError as e:\n                print(f\"Error writing to file: {e}\")\n\n        return len(input_items[0])\n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: np.arange(cov_time)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: tab@1
    marker1: '0'
    marker2: '1'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '500'
    ymin: '100'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@0
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '30'
    corr0: '46'
    freq0: 433.96e6
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}

connections:
- [blocks_char_to_float_0, '0', epy_block_2, '0']
- [blocks_char_to_float_0, '0', epy_block_3, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_mag_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_float_0, '0']
- [dc_blocker_xx_1, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rtlsdr_source_0, '0', dc_blocker_xx_1, '0']

metadata:
  file_format: 1
